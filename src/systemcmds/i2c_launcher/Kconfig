## src/systemcmds/i2c_launcher/Kconfig
```kconfig
menuconfig SYSTEMCMDS_I2C_LAUNCHER
	bool "i2c_launcher"
	default n
	---help---
		Daemon that starts drivers based on found I2C devices.
```
